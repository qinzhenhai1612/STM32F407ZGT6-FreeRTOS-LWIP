# Keil uVision project template.uvprojx, settings and files
target TEMPLATE (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Hardware;..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\System\delay;..\System\sys;..\System\usart;..\User;..\Hardware\KEY;..\Hardware\LCD;..\Hardware\LED;..\Hardware\BEEP;..\Hardware\TIMER;..\Hardware\SRAM;..\MALLOC;..\USMART;..\Libraries\FWlib\STM32F4x7_ETH_Driver\inc;..\Hardware\ETHERNET;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP;..\LWIP\arch;..\LWIP\lwip_app\lwip_comm;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\LWIP\lwip_app\tcp_client_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../Hardware/KEY/: key.c
    ../Hardware/LCD/: lcd.c
    ../Hardware/LED/: led.c
    ../Hardware/SRAM/: sram.c
    ../Hardware/ETHERNET/: lan8720.c
    ../Hardware/BEEP/: beep.c
  group SYSTEM
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
  group STARTUP
    ../Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
    ../Libraries/FWlib/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group LWIP_NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c lwip_sys.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP_APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/tcp_client_demo/: tcp_client_demo.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group DOC
    ../Doc/: Readme.txt
